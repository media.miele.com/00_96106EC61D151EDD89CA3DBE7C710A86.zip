Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-08-24T13:56:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 24 13:56:09 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\77a348be-1e8e-4943-9d6a-3237e4e984f1\7c1f196d-78de-4d40-8890-b20ebd2a99cb\ifc * Database version: 5507 * Database creation date: Wed Aug 24 13:56:08 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 24 13:56:09 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 24 13:56:09 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12094520_F_DGC7640HCPro_BRWS:23764018_F_12094520_DGC7640HCPro_BRWS, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 23764018_F_12094520_DGC7640HCPro_BRWS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 23764018_F_12094520_DGC7640HCPro_BRWS
Type - Pset_ProvisionForVoid - Depth: 569 mm
Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm

# IfcDistributionPort, Port_353505
Description: Flow; FlowDirection: SOURCEANDSINK
